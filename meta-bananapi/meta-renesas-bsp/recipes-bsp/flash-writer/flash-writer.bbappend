SRC_URI:append:bananapi-g3l = " file://Flash_Writer_SCIF_RZG3L_SMARC_LPDDR4.mot"
