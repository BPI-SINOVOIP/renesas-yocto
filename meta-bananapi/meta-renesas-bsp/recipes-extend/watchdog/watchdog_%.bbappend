# Enable watchdog service for all machines except RZ/V2H
SYSTEMD_AUTO_ENABLE:bananapi-ai2h = "disable"
