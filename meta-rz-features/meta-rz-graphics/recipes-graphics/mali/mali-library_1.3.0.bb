include mali-library.inc

PR="r54"
