SRC_URI:append = " \
    file://0001-dmaengine-sh-rz-dmac-Protect-the-driver-specific-lis.patch \
"
